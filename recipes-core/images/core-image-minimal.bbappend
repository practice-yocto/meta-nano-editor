IMAGE_INSTALL += "nano"