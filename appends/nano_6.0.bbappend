inherit rm_work